# IAR project Backup of DS0201.ewp, settings and files
configuration Debug_FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: STM32F10x ST STM32F10x
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\..\..\USBLib\inc; ..\..\..\library\inc; ..\..\..\USBLib\inc; ..\..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration Debug_RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\..\FWLib\library\inc; ..\..\..\..\library\inc; ..\..\include
  XLINK.XclFile: lnkarm_ram.xcl
  group Application
    ../../source/: Calculate.c Files.c Function.c HW_V1_Config.c Lcd.c main.c memory.c msd.c scsi_data.c stm32f10x_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group STlib
    ../../../library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c
  group USBlib
    ../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
