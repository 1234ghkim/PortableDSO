# IAR project DS0201.ewp, settings and files
configuration Debug_FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\DSO_NANO\DS0201_opensource for IAR5.0\DS0201\DS0201\DS0201_APP\include; C:\DSO_NANO\DS0201_opensource for IAR5.0\DS0201\DS0201\library\inc; C:\DSO_NANO\DS0201_opensource for IAR5.0\DS0201\DS0201\USBLib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: DS0201.out
configuration Debug_RAM (ARM, debug)
  as the first configuration, except:
  group Application
    ../../source/: Calculate.c Files.c Function.c HW_V1_Config.c Lcd.c main.c memory.c msd.c scsi_data.c stm32f10x_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group STlib
    ../../../library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c
  group USBlib
    ../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
