# IAR project Backup of DFU.ewp, settings and files
configuration Debug_FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10x ST STM32F10x
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\library\inc; ..\..\..\USBLib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration Debug_RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_RAM
  ICCARM.CCIncludePath2: ..\..\include\; ..\..\..\..\library\inc\; ..\..\..\..\..\FWLib\library\inc
  XLINK.XclFile: lnkarm_ram.xcl
  group Application
    ../../source/: hw_config.c main.c spi_flash.c stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group STLib
    ../../../library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c
  group USBLib
    ../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
